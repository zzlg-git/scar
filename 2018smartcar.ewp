# IAR project 2018smartcar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: source\ad; source\common; source\cpu; source\drivers; source\schedule; source\filter; source\fuzzycontrol; source\keyset; source\BMX055
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: source\schedule; source\ad; source\common; source\cpu; source\drivers
  OBJCOPY.OOCOutputFile: 2016smartcar.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: source\link\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    source/: main.c
  group common
    source/common/: common.h keyboard_oled.c keyboard_oled.h systeminit.c systeminit.h
  group cpu
    source/cpu/: clkinit.c clkinit.h core.c core.h crt0.s start.c start.h vectors.c vectors.h
  group drivers
    source/drivers/: 3IN1.c 3IN1.h adc.c adc.h BMX055.c BMX055.h flash.c flash.h gpio.c gpio.h iicsoft.c iicsoft.h interrupt.c interrupt.h mcg.c mcg.h MPU9250.c MPU9250.h MPU9250_api.h pulse_counter.c pulse_counter.h pwm.c pwm.h sccb.c sccb.h sensoroperation.c sensoroperation.h spi.c spi.h spisoft.c spisoft.h timer.c timer.h uart.c uart.h wdog.c wdog.h
  group link
    source/link/: Pflash.icf Ram.icf
  group schedule
    source/schedule/: Attitude_Calculation.c Attitude_Calculation.h mathadd.c mathadd.h schedule.c schedule.h
